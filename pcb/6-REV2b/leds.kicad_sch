File: pcb/6-REV2b/leds.kicad_sch (KiCad schematic)
At the start: 37 parts

Commit message: reorg, but forgot to check changes first :(
Parts:
- gave numbers to parts that had none: 29
